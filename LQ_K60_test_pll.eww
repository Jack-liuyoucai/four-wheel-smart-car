<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LQ_K60_test_pll.ewp</path>
  </project>
  <batchBuild/>
</workspace>


