# IAR project LQ_K60_test_pll.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCIncludePath2: src\Sources\H; src\Sources\H\Component_H; src\Sources\H\Frame_H
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: light.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  OBJCOPY.OOCOutputFile: LQ_K60_test_pll.srec
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Pflash.icf
  group Project_Settings/link
    src/Project_Settings/Link/: Pflash.icf Ram.icf
  group Project_Settings/Startup_Code
    src/Project_Settings/Startup_Code/: crt0.s start.c
  group Project_Settings/Startup_Code/Sources/C
    src/Sources/C/: isr.c LCDDriver.c main.c
    src/Sources/H/: isr.h LCDDriver.h
  group Project_Settings/Startup_Code/Sources/C/Component_C
    src/Sources/C/Component_C/: gpio.c light.c uart.c wdog.c
  group Project_Settings/Startup_Code/Sources/C/Frame_C
    src/Sources/C/Frame_C/: common.c sysinit.c vectors.c
  group Project_Settings/Startup_Code/Sources/H
    src/Sources/H/: includes.h
  group Project_Settings/Startup_Code/Sources/H/Component_H
    src/Sources/H/Component_H/: gpio.h light.h uart.h wdog.h
  group Project_Settings/Startup_Code/Sources/H/Frame_H
    src/Sources/H/Frame_H/: common.h MK60N512VMD100.h sysinit.h vectors.h
